<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\03_UART_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>
