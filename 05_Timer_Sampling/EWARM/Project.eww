<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\05_Timer_Sampling.ewp</path>
  </project>
  <batchBuild />
</workspace>
